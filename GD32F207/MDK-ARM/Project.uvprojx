# Keil uVision project Project.uvprojx, settings and files
target GD32F207 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F207VG GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL,GD32F207debug
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\GD\GD32F20x\Include;..\..\Libraries\GD32F20x_standard_peripheral\Include;..\;..\..\Third_Party\LVGL\lvgl;..\..\Third_Party\LVGL\lvgl\src;..\LVGL_driver;..\..\LVGL-APP;..\..\Third_Party\LVGL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Startup
    ../../Libraries/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group CMSIS
    ../../Libraries/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Peripherals
    ../../Libraries/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group main
    ../: main.c gd32f20x_it.c LCD_disp.c Key.c
  group LVGL
    ../../Third_Party/LVGL/: lv_conf.h
    ../../Third_Party/LVGL/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ../../Third_Party/LVGL/lvgl/src/draw/: lv_draw_arc.c lv_draw_arc.h lv_draw_blend.c lv_draw_blend.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h lv_draw.h
    ../../Third_Party/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ../../Third_Party/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ../../Third_Party/LVGL/lvgl/src/extra/layouts/: lv_layouts.h
    ../../Third_Party/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../../Third_Party/LVGL/lvgl/src/extra/others/: lv_others.h
    ../../Third_Party/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ../../Third_Party/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ../../Third_Party/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../../Third_Party/LVGL/lvgl/src/extra/themes/: lv_themes.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
    ../../Third_Party/LVGL/lvgl/src/extra/widgets/: lv_widgets.h
    ../../Third_Party/LVGL/lvgl/src/extra/: lv_extra.c lv_extra.h
    ../../Third_Party/LVGL/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../../Third_Party/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h lv_hal.h
    ../../Third_Party/LVGL/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
    ../../Third_Party/LVGL/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
    ../../Third_Party/LVGL/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group LVGL_driver
    ../LVGL_driver/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_app
    ../../LVGL-APP/: lvgl_app.c lvgl_app.h
